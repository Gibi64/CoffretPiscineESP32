#include "CProtocoleModbus.h"
#include "CTimeUtils.hpp"
#include <cmath>
//*****************************************************
CProtocoleModBus::CProtocoleModBus()
	: nWaitingBytes(0)
{
	m_Name = "ModBus";
	TimeOut = 20L;
	bOpen = false;
	bCommand = false;
	bStillWaitingforAnswer = false;

}

void CProtocoleModBus::EnvoieCommande()
{

	int adresse = (int)Parametre[1];
	float valeur = (float)Parametre[2];
	int Registre = (int)Parametre[3];
	int TypeOfValue;
	int NumberOfBytes = (int)Parametre[4];
	TypeOfValue = (int)Parametre[4];
	Commande[0] = adresse;

	Commande[1] = 16;
	Commande[2] = Registre / 256;
	Commande[3] = Registre - 256 * (Registre / 256);
	Commande[4] = 0;

	switch (TypeOfValue)
	{
	case 1:
	{
		// Type Integer
		int nValue = (int)valeur;
		Commande[5] = NumberOfBytes;
		Commande[6] = 2 * NumberOfBytes;
		Commande[7] = (int)nValue / 256;
		Commande[8] = nValue - (nValue / 256) * 256;
		break;
	}
	case 2:
	{
		// Type real
		int nValue = (int)valeur;
		Commande[5] = NumberOfBytes;
		Commande[6] = 2 * NumberOfBytes;
		*((float*)&Commande[7]) = valeur;
		break;
	}
	case 3:
	{
		//
		// Masque de Bit : la fonction n'est pas 16 mais 5
		Commande[1] = 5;
		if (valeur > 0)
		{
			//			And Mask
			Commande[5] = 0;
			Commande[6] = 0;
			//			Or Mask
			int iBit = (int)Parametre[5];
			Commande[7] = 0;
			Commande[8] = (char)pow(2, iBit);
		}
		else
		{
			int iBit = (int)Parametre[5];
			// And Mask

			Commande[5] = 0;
			int iMask = 0;
			/*for (int iDigit = 0;iDigit<8;iDigit++)
			{
				if (iDigit != iBit) iMask += (long) pow((long double) 2,(int)iDigit);
			}*/
			iMask = (long)pow((long double)2, (int)iBit);
			Commande[6] = iMask;
			// Or Mask
			Commande[7] = 0;
			Commande[8] = 0;
		}
		NumberOfBytes = 1;

		break;
	}
	}

	unsigned short uCrc = crc((unsigned char*)Commande.c_str(), 7 + 2 * NumberOfBytes);
	Commande[7 + 2 * NumberOfBytes] = uCrc - (uCrc / 256) * 256;
	Commande[7 + 2 * NumberOfBytes + 1] = uCrc / 256;
	pLigne->sendArray((char *)Commande.c_str(), 7 + 2 * NumberOfBytes + 2);
	TimeEnd = (float)CTimeUtils::GetMs() + TimeOut;
	int nReceived = 0;
	while ((float)CTimeUtils::GetMs()  < TimeEnd)
	{
		nReceived += AttenteRetourCommande();
		if (nReceived >= 8) break;
	}
	bCommand = false;
}
int CProtocoleModBus::AttenteRetourCommande()
{
	char c;
	auto nB = pLigne->getArray(&c, 1);
	if (nB) (*GetBufferReponse()) = c;
	return nB;

}
void CProtocoleModBus::EnvoieTrameQuestion(CExternalVariable* pVar)
{

	int noctet = 8;
	unsigned char bfc[20];

	bfc[0] = pVar->AdressOfCard;
	bfc[1] = 3;
	bfc[2] = pVar->Register / 256;
	bfc[3] = pVar->Register - 256 * bfc[2];
	bfc[4] = pVar->NumberOfRegistersToRead / 256;
	bfc[5] = pVar->NumberOfRegistersToRead - bfc[4] * 256;
	unsigned short uCrc = crc(bfc, 6);
	bfc[6] = uCrc - (uCrc / 256) * 256;
	bfc[7] = uCrc / 256;
	nWaitingBytes = pVar->NumberOfRegistersToRead * 2;
	TimeEnd = (float)CTimeUtils::GetMs()+ TimeOut;

	pLigne->sendArray((char*)bfc, 8);


}
int CProtocoleModBus::AttenteTrameQuestion()
{
	bool bFind = false;

	int nBytes = 0;
	//TODO : restore while ( (float) CTimeUtils::GetMs()/CLOCKS_PER_SEC*1000 <= TimeEnd && !bFind)
	while (!bFind)

	{
		if (CProtocole::AttenteTrameQuestion())
		{
			char c = (*GetBufferReponse())[nReceive - 1];
			if (c == 2)
			{
				// lecture code adresse
				if ((*GetBufferReponse())[1] > 128)
				{
					write_log("Erreur Code : " + GetBufferReponse()[1]);
				}
			}
			if (nReceive > 3)
			{
				nBytes = (*GetBufferReponse())[2];

				bool bByteOk = false;
				while (!bByteOk && nReceive > 3)
				{
					if (nBytes != nWaitingBytes)
					{
						write_log("Warning :Received Bytes %d differed from expected" + std::to_string( nBytes) + "vs :" + std::to_string(nWaitingBytes));
						for (int jDecal = 1; jDecal < nReceive; jDecal++)
							(*GetBufferReponse())[jDecal - 1] = (*GetBufferReponse())[jDecal];
						GetBufferReponse()->pop_back();
					}
					else
					{

						if ((*GetBufferReponse())[1] == 3)
						{
							bByteOk = true;
							//							fprintf(ptrLog,"Byte et code Ok \n");
						}
					}
				}
				if (nReceive >= 3 + 2 + nWaitingBytes)
				{
					nBytes = (*GetBufferReponse())[2];
					unsigned char vBuffer[4];

					for (int j = 3; j < 3 + nBytes; j++)
					{
						vBuffer[j - 3] = (unsigned char)(*GetBufferReponse())[j];
					}
					bFind = true;
					//fprintf(ptrLog,"Reponse octet: ");
					//for (int j=0;j<5+nBytes;j++) fprintf(ptrLog,"%d ",(UCHAR)pLigne->BufferReponse[j]);
					//fprintf(ptrLog,"\n");
					int lMax = 512;
					char* Mem = new char[lMax + 1];
					memset(Mem, 0, lMax + 1);
					switch (nBytes)
					{
					case 1:
					#if defined(_WINDOWS)
						sprintf_s(Mem, lMax, "%d", vBuffer[0]);
						xValues[0] = atoi(Mem);

						break;
					#else
						sprintf(Mem, "%d", vBuffer[0]);
						xValues[0] = atoi(Mem);

						break;
					#endif
					case 2:
					#if defined(_WINDOWS)	
						sprintf_s(Mem, lMax, "%d", 256 * vBuffer[0] + vBuffer[1]);
						xValues[0] = 256 * vBuffer[0] + vBuffer[1];
						break;
					#else
						sprintf(Mem, "%d", 256 * vBuffer[0] + vBuffer[1]);
						xValues[0] = 256 * vBuffer[0] + vBuffer[1];
						break;
					#endif
					case 4:
					#if defined(_WINDOWS)
						float x = *(float*)&vBuffer[0];
						sprintf_s(Mem, lMax, "%.6e", x);
						xValues[0] = x;

						break;
					#else
						float x = *(float*)&vBuffer[0];
						sprintf(Mem, "%.6e", x);
						xValues[0] = x;

						break;
					#endif
					}
					BufferReponse = Mem;
					delete[] Mem;
				}
			}
		}
	}
	bStillWaitingforAnswer = false;
	if ((float)CTimeUtils::GetMs() > TimeEnd)
	{
		write_log("Time Out Modbus longueur re�ue : "+ std::to_string(nReceive) + " sur " + std::to_string(3 + 2 + nBytes) + " - Temps " + std::to_string((float)CTimeUtils::GetMs()) + " ms\n");
		bFind = true;
	}
	return bFind;

}
extern "C" void Crc16(char* ptc, int nc);



double CProtocoleModBus::Conversion(std::string sReponse, std::string sTrame, CSortie* pSor)
{

	int k = (int)sTrame.find("/");
	double x;
	if (k == -1)
	{
		int MotaLire = (atoi((char*)sTrame.data()) - MOTINIT) * 2 + 3;
		//		x=Decode_Jbus((BYTE)sReponse.at(MotaLire),(BYTE)sReponse.at(MotaLire+1));
	}
	else
	{
		int MotaLire = (atoi((char*)sTrame.data()) - MOTINIT) * 2 + 4;
		unsigned char BitaLire = atoi((char*)sTrame.at(k + 1));
		if (BitaLire > 7)
		{
			BitaLire -= 8;
			--MotaLire;
		}
		x = (((1 << BitaLire) & ((unsigned char)sReponse.at(MotaLire))) > 0);
	}

	return (pSor->Gain * x + pSor->Offset);
}

unsigned short CProtocoleModBus::crc(unsigned char* pucFrame, unsigned short usLen)
{

	static const unsigned char aucCRCHi[] = {
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40
	};

	static const unsigned char aucCRCLo[] = {
		0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
		0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
		0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
		0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
		0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
		0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
		0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
		0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38,
		0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
		0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
		0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
		0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
		0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB,
		0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
		0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
		0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
		0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
		0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
		0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
		0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
		0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
		0x41, 0x81, 0x80, 0x40
	};
	unsigned char           ucCRCHi = 0xFF;
	unsigned char           ucCRCLo = 0xFF;
	int             iIndex;

	while (usLen--)
	{
		iIndex = ucCRCLo ^ *(pucFrame++);
		ucCRCLo = (unsigned char)(ucCRCHi ^ aucCRCHi[iIndex]);
		ucCRCHi = aucCRCLo[iIndex];
	}
	return (unsigned short)(ucCRCHi << 8 | ucCRCLo);


}
